# Keil uVision project single soc.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: RN8213 Renergy
  cpu: IRAM(0x10000000-0x10001fff) IROM(0-0x1ffff) CLOCK(3686400) CPUTYPE("Cortex-M0")
  output: single_soc +hex
  AfterMake: fromelf --bin -o uVision\signle_soc.bin uVision\single_soc.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\systeminclude;.\App;.\Drive;.\LIB
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group App
    ./App/: Dl645_Bkgrd.c Dl645_Disp.C Dl645_File.c Dl645_Front.C Dl645_Globals.c Dl645B_Com.c main.c Memory.c Scom.c Dl645_ICEsam.c startup_RN8213.s
  group Drive
    ./Drive/: Drive_AllINT.c Drive_Clock.c Fm24Cxx.c Key.c LcdDrive.c MyMath.c RTCDrive.c SystemInit.c Uart.c ISO7816.c
  group DriveLib
    ./LIB/: rn821x_sysctrl.lib rn821x_nvm.lib rn821x_rtc.lib
